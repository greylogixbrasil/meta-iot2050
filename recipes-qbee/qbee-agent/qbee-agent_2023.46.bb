inherit dpkg-prebuilt

SRC_URI = "https://cdn.qbee.io/software/qbee-agent/2023.46/packages/qbee-agent_2023.46_arm64.deb"
